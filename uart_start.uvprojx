# Keil uVision project uart_start.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uart_start
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: main.c input_pa0.c input_pa0.h LED.c LED.h stm32l476xx.h SysClock.c SysClock.h UART.c UART.h startup_stm32l476xx.s Timer.c
software components: CMSIS:CORE 4.3.0
